# Keil uVision project fmwk51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: fmwk51 +hex
  c flags: Optimize=9
  group Source Group 1
    ./: main.c defs.h lcd12864.c lcd12864.h misc.c misc.h keyboard.h keyboard.c i2c.c i2c.h at24c02.c at24c02.h xpt2046.h xpt2046.c pwm.c pwm.h ds18b20.c ds18b20.h
